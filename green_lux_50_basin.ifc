Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: green_lux_50_basin.ifc
Time: 2017-10-05T13:48:36
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2015
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: Green Lux 50 Basin
ePset_BIMobject_Lena - GREEN_LUX_COLOUR: Glossy_Withe; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Green Lux 50 Basin; SKU (BO_prodsku): catalano_basin_green_lux_50x38_cod_150AGRLX00; ManufacturName (BO_Manufac): Ceramica Catalano; BrandUrl (BO_brandurl): http://www.catalano.it/; ProductFamily (BO_prodfam): Green Lux; ProductGroup (BO_prodgroup): Basin; ManufacturCountry (BO_mancont): Italy; DesignCountry (BO_designcont): Italy; PublishDate (BO_publisdat): 10/2/2017; EditionNumber (BO_edinum): 1; Width (BO_width): 500; Height (BO_height): 140; Depth (BO_depth): 380; Weight (BO_weight): 9; QR (BO_boqrurl): http://bimobject.com/ceramica-catalano/product/catalano_basin_green_lux_50x38_cod_150AGRLX00; ProductDataUrl (BO_prodaturl): bimobject.com/ceramica-catalano/product/catalano_basin_green_lux_50x38_cod_150AGRLX00; ProductUrl (BO_producturl): http://www.catalano.it/it/prodotti/green/green-lux-50x38-150agrlx00/; ProductCertification (BO_prodcert): http://www.ceramicacatalano.it/conformita/Declaration-of-Performance-Washbasin.pdf; TechnicalDescription (BO_techcert): http://www.ceramicacatalano.it/allegati_schede/schede-tecniche/GREEN/150AGRLX00.pdf; EanCode (BO_ean): 8055348937923; MaterialMain (BO_mainmat): Ceramics; MaterialSecondary (BO_secmat): Fireclay; BimObjectCategory (BO_bocat): Basins; IfcClassification (BO_ifcclas): Sanitary Terminal; UnspcCode (BO_unspc): 301815; Uniclass14Code (BO_uniclass_1_4_code): L7212; Uniclass14Description (BO_uniclass_1_4_desc): Washbasins; Uniclass20Code (BO_uniclass_2_0_code): SS-35-65-70-94; Uniclass20Description (BO_uniclass_2_0_desc): Wash Basin Systems; Uniclass2015Code (BO_uniclass2015_code): Pr_40_20_87_96; Uniclass2015Description (BO_uniclass2015_desc): Washbasin manual water supply sets; NBSReference (BO_nbs_ref): 35-65-70-94; NBSReferenceDescription (BO_nbs_desc): Wash Basin Systems; OmniClassCode (BO_omniclass_code): 23-31 13 00; OmniClassDescription (BO_omniclass_name): Sinks; MasterFormat2014Code (BO_masterformat2014_code): 22 41 16.16; MasterFormat2014Description (BO_masterformat2014_name): Residential Sinks; UniFormat2Code (BO_uniformat2_code): C10; UniFormat2Description (BO_uniformat2_name): INTERIOR CONSTRUCTION; RegionEurope (BO_europe): AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA; RegionNorthAmerica (BO_northamerica): AG, AI, AW, BB, BL, BM, BQ, BS, BZ, CA, CR, CU, CW, DM, DO, GD, GL, GP, GT, HN, HT, JM, KN, KY, LC, MF, MQ, MS, MX, NI, PA, PM, PR, SV, SX, TC, TT, US, VC, VG, VI; RegionSouthAmerica (BO_southamerica): AR, BO, BR, CL, CO, EC, FK, GF, GY, PE, PY, SR, UY, VE; RegionMiddleEast (BO_middleeast): AE, AF, BH, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, SY, TR, YE; RegionAsia (BO_asia): AM, AZ, BD, BN, BT, CC, CN, CX, GE, HK, ID, IN, IO, JP, KG, KH, KP, KR, KZ, LA, LK, MM, MN, MO, MV, MY, NP, PH, PK, SG, TH, TJ, TM, TW, UZ, VN; RegionOceania (BO_oceania): AS, AU, CK, FJ, FM, GU, KI, MH, MP, NC, NF, NR, NU, NZ, PF, PG, PN, PW, SB, TK, TL, TO, TV, UM, WF, WS, VU; RegionAfrica (BO_africa): AO, BF, BI, BJ, BW, CD, CF, CG, CI, CM, CV, DJ, DZ, EH, ER, ET, GA, GH, GM, GN, GQ, GW, KE, KM, LR, LS, LY, MA, MG, ML, MR, MU, MW, MZ, NA, NE, NG, RE, RW, SC, SD, SH, SL, SN, SO, SS, ST, SZ, TD, TG, TN, TZ, UG, YT, ZA, ZM, ZW
